# Install wpa_supplicant configuration file

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://beast_part_file.patch" 


